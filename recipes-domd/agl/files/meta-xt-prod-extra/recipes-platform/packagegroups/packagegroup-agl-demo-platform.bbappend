AGL_APPS_append = " \
    aglsurfaceswitcher \
"

AGL_APPS_remove = " \
    dashboard \
"

