# Append domain name
hostname += "-domd"
