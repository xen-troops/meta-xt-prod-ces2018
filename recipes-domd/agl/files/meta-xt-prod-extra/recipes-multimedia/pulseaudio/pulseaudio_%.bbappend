# remote module-router as it is not functional
SRC_URI_remove =  "file://0006-auto-load-module-router.patch"
